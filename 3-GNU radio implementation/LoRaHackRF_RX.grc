options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: LoRaHackRF_RX
    output_language: python
    title: LoRaHackRF_RX
  states: {}

blocks:
- name: Idro
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: Pn
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Potentiel of the noise
    start: '0'
    step: 1/100
    stop: '1'
    value: '0'
  states: {state: disabled}
- name: Rb
  id: variable
  parameters:
    value: (sf*bw)/(2**sf)
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/sf
  states: {}
- name: Sps
  id: variable
  parameters:
    value: (samp_rate*sf)/Rb
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: clk_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ndisp
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: packet_len*400
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '250'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: 256*8
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw*8
  states: {}
- name: sf
  id: variable
  parameters:
    value: '12'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt(Pn)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: num_samples
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_2
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/8
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class inversedB(gr.sync_block):  

          def __init__(self, ): 
              gr.sync_block.__init__(
                  self,
                  name='e_inversedB_ff',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              y[:]=np.power(10,x)
              return len(y)
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    maxoutbuf: '8192'
    os_factor: int(samp_rate/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {state: disabled}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '0'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {state: disabled}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    preamb_len: preamb_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '0x12'
  states: {state: disabled}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''';'''
    source_type: file_source
    use_length_tag: 'True'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '-7'
    name: BER between Tx and Rx
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx bitstream"'
    size: '32'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_2_2_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: modulate
    size: ndisp
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: Comparison bits
    nconnections: '2'
    size: ndisp
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.0010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: t5
  states: {state: disabled}
- name: virtual_sink_0_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: r5
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: r5
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_random_source_x_0, '0', blocks_skiphead_0_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_2, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0_0_1_0, '0']
- [blocks_add_xx_1, '0', lora_sdr_frame_sync_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_2_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_delay_0, '0', fec_ber_bf_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_skiphead_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_skiphead_0, '0', fec_ber_bf_0, '1']
- [blocks_skiphead_0_0, '0', blocks_delay_0, '0']
- [blocks_stream_to_tagged_stream_2, '0', lora_sdr_whitening_0, '0']
- [blocks_throttle2_1, '0', blocks_add_xx_1, '1']
- [blocks_throttle2_1_0, '0', lora_sdr_frame_sync_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [fec_ber_bf_0, '0', epy_block_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_char_to_float_0_1_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_file_sink_0, '0']
- [lora_sdr_dewhitening_0, '0', virtual_sink_0_0_0_1_0_0, '0']
- [lora_sdr_fft_demod_1, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_1, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle2_1, '0']
- [lora_sdr_modulate_0, '0', qtgui_time_sink_x_0_2_2_0_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [soapy_hackrf_source_0, '0', blocks_throttle2_1_0, '0']
- [soapy_hackrf_source_0, '0', lora_sdr_frame_sync_0, '0']
- [virtual_source_0_0_0_0_0_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
