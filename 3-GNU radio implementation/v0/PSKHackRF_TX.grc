options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: PSKHackRF_TX
    output_language: python
    title: PSKHackRF_TX
  states: {}

blocks:
- name: Fmax
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: M
  id: variable
  parameters:
    value: len(constellation )
  states: {}
- name: Pn
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Potentiel of the noise
    start: '0'
    step: 1/100
    stop: '1'
    value: '0'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '400'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '40'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: constellation
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: delay
  id: variable
  parameters:
    value: '16'
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps,beta)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 16*Sps
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt(Pn)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: num_samples
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_1_0_0_0
  id: blocks_delay
  parameters:
    delay: delay*bps
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 16*bps
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: 16*bps
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: '[16,num_samples]'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (1,0, 1, 0, 1, 0, 1, 0, 1,0 ,1,0,  1,0, 1,0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constellation
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0.5'
    omega: Sps*(1+0.0)
    omega_relative_limit: '0.05'
    type: complex
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class inversedB(gr.sync_block):  

          def __init__(self, ): 
              gr.sync_block.__init__(
                  self,
                  name='e_inversedB_ff',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              y[:]=np.power(10,x)
              return len(y)
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h
    type: ccf
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: p1
    label2: r1
    name: Interpolating Filter FIR
    nconnections: '2'
    type: complex
    width1: '3'
    width2: '3'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: BER between Tx and Rx
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: Comparison bits
    nconnections: '2'
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: bw
    center_freq: center_freq
    dev_args: driver=hackrf
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r
  states: {state: disabled}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: t
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {state: disabled}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: r
  states: {state: disabled}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: t
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: r1
  states: {state: disabled}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
      ########################################################
      ##     Bipolar non return to zero level signal        ##
      ########################################################
      def B_NRZ_L(Sps):
          return Sps*[1.,]

      ########################################################
      ##  Forma sinc . Es la misma nyq() que aparece arriba ##
      ########################################################
      def sinc(Sps,ntaps):
          n=np.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=np.sinc(n/Sps)
          return h
      ########################################################
      ##              forma diente se sierra                ##
      ########################################################
      def saw(Sps):
          return np.linspace(0,Sps-1,Sps)	
      ########################################################
      #         Bipolar non return to zero signal           ##
      ########################################################
      def RZ(Sps):
          h=Sps*[1.,]
          Sps_m=int(Sps/2)
          h[Sps_m+1:Sps:1]=np.zeros(Sps-Sps_m)
          return h
  states: {}

connections:
- [analog_agc3_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_mux_1, '1']
- [blocks_add_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_2, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_2_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_delay_1_0_0_0, '0', blocks_skiphead_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_skiphead_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_skiphead_0, '0', fec_ber_bf_0, '1']
- [blocks_skiphead_0_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_skiphead_0_0, '0', fec_ber_bf_0, '0']
- [blocks_stream_mux_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_stream_mux_1, '0', virtual_sink_0_0_0_1_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', analog_agc3_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [fec_ber_bf_0, '0', epy_block_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [interp_fir_filter_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0_0_0_0_0, '0', blocks_skiphead_0, '0']
- [virtual_source_0_0_0_0_1, '0', blocks_delay_1_0_0_0, '0']
- [virtual_source_0_1, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
