options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: SixteenFSKRX
    output_language: python
    title: 16FSKRX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '16'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: (sf_lora*bw_lora)/2**sf_lora
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: int((bps*samp_rate)/Rb)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: bw
  id: variable
  parameters:
    value: (2**m)*Rb/m
  states: {}
- name: bw_lora
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: bw/m
  states: {}
- name: m
  id: variable
  parameters:
    value: int(math.log2(M))
  states: {}
- name: ndisp
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '240'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf_lora
  id: variable
  parameters:
    value: '7'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '7'
    type: float
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR files of bits\16FSKsdroutput
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: Sps
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: Sps
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: m
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00110011011000111'
    tagname: preamble_detected
    threshold: '1'
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: after noise
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '6'
    ymin: '-7'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: Rx Bits
    size: ndisp
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_char_to_float_0_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_repeat_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_repeat_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [soapy_hackrf_source_0, '0', analog_quadrature_demod_cf_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
