options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: LoRaRX
    output_language: python
    title: LoRaRX
  states: {}

blocks:
- name: Idro
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: (sf*bw)/(2**sf)
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/sf
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: clk_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: eb_n0_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Eb/N0
    start: '-5'
    step: 1/100
    stop: '15'
    value: '10'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ndisp
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: noise_power
  id: variable
  parameters:
    value: ((sig_power*bw)/Rb)*10**(-eb_n0_dB/10)
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '250'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: packet_len
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sig_power
  id: variable
  parameters:
    value: '1'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR files of bits\LoRasdroutputSNR15
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_1
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: '3'
    has_crc: 'False'
    impl_head: impl_head
    ldro: '0'
    pay_len: '255'
    print_header: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: after frame sync
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: after demod
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    name: after received
    size: ndisp
    srate: samp_rate
    type: complex
    update_time: '0.20'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: '32'
    samp_rate: '1000000'
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_1_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_char_to_float_0_1_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_pack_k_bits_bb_0, '0']
- [lora_sdr_fft_demod_1, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_1, '0']
- [lora_sdr_frame_sync_0, '0', qtgui_time_sink_x_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [soapy_hackrf_source_0, '0', lora_sdr_frame_sync_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
