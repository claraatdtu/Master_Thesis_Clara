options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: FourFSKRX
    output_language: python
    title: 4FSKRX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '400'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '40'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: bw
  id: variable
  parameters:
    value: (2**m)*Rb/m
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: eb_n0_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Eb/N0
    start: '-5'
    step: 1/100
    stop: '15'
    value: '15'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: bw/2
  states: {}
- name: m
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ndisp
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: noise_power
  id: variable
  parameters:
    value: (sig_power*bw/(Sps*Rs))*10**(-eb_n0_dB/10)
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '240'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (Sps*Rb)/bps
  states: {}
- name: sig_power
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR files of bits\4FSKsdroutput
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: Sps
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: Sps
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: after noise
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: Rx Bits
    size: ndisp
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: r
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_char_to_float_0_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_repeat_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_repeat_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', virtual_sink_0_0_0_1_0_0, '0']
- [soapy_hackrf_source_0, '0', analog_quadrature_demod_cf_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
