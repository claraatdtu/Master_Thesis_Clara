options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: QPSKRX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Fmax
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: M
  id: variable
  parameters:
    value: len(constellation )
  states: {}
- name: Rb
  id: variable
  parameters:
    value: (sf_lora*bw_lora)/2**sf_lora
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: int((bps*samp_rate)/Rb)
  states: {}
- name: beta
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: bw
  id: variable
  parameters:
    value: (2**m)*Rb/m
  states: {}
- name: bw_lora
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: constellation
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: delay
  id: variable
  parameters:
    value: bps*8
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps,beta)
  states: {}
- name: m
  id: variable
  parameters:
    value: int(math.log2(M))
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 16*Sps
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '240'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    sym_map: '[0,1,3,2]'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf_lora
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sig_power
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '0.5'
    iir_update_decim: '1'
    max_gain: '1'
    reference: '1'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-30'
    type: complex
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR files of bits\QPSKsdroutput_bytes
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '100'
    init: '0'
    low: '-100'
  states: {state: disabled}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '2'
    init: '0'
    low: '0.3'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0.5'
    omega: Sps*(1+0.0)
    omega_relative_limit: '0.05'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    use_snr: 'True'
    w: '0.0628'
  states: {state: disabled}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h
    type: ccf
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: bw*8
    fc: center_freq
    fftsize: '1024'
    name: constell
    showports: 'True'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    marker1: '0'
    name: Comparison bits
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: float
    update_time: '0.010'
    width1: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: after
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: BEFORE squelch
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: after const
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: after clock reco
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: after agc
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: AFTER squelch
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: complex
    update_time: '0.010'
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    dev_args: clock=external
    gain: '0'
    samp_rate: '1000000'
    type: fc32
    vga: '0'
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
      ########################################################
      ##     Bipolar non return to zero level signal        ##
      ########################################################
      def B_NRZ_L(Sps):
          return Sps*[1.,]

      ########################################################
      ##  Forma sinc . Es la misma nyq() que aparece arriba ##
      ########################################################
      def sinc(Sps,ntaps):
          n=np.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=np.sinc(n/Sps)
          return h
      ########################################################
      ##              forma diente se sierra                ##
      ########################################################
      def saw(Sps):
          return np.linspace(0,Sps-1,Sps)	
      ########################################################
      #         Bipolar non return to zero signal           ##
      ########################################################
      def RZ(Sps):
          h=Sps*[1.,]
          Sps_m=int(Sps/2)
          h[Sps_m+1:Sps:1]=np.zeros(Sps-Sps_m)
          return h
  states: {}

connections:
- [analog_agc3_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_agc3_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [analog_agc3_xx_0, '0', digital_costas_loop_cc_0, '0']
- [analog_agc3_xx_0, '0', qtgui_time_sink_x_2_0_0_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_2_0_0_0_1, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_char_to_float_0_1_1, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_1, '0']
- [blocks_float_to_complex_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_complex_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_complex_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', analog_agc3_xx_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', qtgui_time_sink_x_2_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0_1_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_hackrf_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [soapy_hackrf_source_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_2_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
