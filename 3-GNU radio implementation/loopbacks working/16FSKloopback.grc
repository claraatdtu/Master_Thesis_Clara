options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: SixteenFSKloopback
    output_language: python
    title: 16FSKloopback
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '16'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: (sf_lora*bw_lora)/2**sf_lora
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: int((bps*samp_rate)/Rb)
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: bw
  id: variable
  parameters:
    value: (2**m)*Rb/m
  states: {}
- name: bw_lora
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: eb_n0_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Eb/N0
    start: '-5'
    step: 1/100
    stop: '15'
    value: '15'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: bw/m
  states: {}
- name: m
  id: variable
  parameters:
    value: int(math.log2(M))
  states: {}
- name: ndisp
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: noise_power
  id: variable
  parameters:
    value: 1 / (2 * m* 10**(eb_n0_dB / 10))
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '240'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf_lora
  id: variable
  parameters:
    value: '12'
  states: {}
- name: sig_power
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2*math.pi*fsk_deviation)/samp_rate
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: math.sqrt(2*noise_power)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: Bits Generation
    max: '2'
    min: '0'
    num_samps: num_samples
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '7'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '7'
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_1_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR files of bits\16FSKsdroutput-5
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR bandwidths\16FSKbw12
    type: float
    vlen: '1024'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\clsor\OneDrive\Documents\MATLAB\Master_Thesis_Clara\Master_Thesis_Clara\3-GNU radio implementation\SDR files of bits\sdrinput
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: Sps
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate/(2*math.pi*fsk_deviation)
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: m
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: Sps
    type: byte
  states: {}
- name: blocks_repeat_0_0_0_0
  id: blocks_repeat
  parameters:
    interp: Sps
    type: byte
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: Sps
    type: float
  states: {}
- name: blocks_skiphead_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: '0'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: m
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: float
    vlen: '1024'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-7, -6, -5, -4, -3, -2, -1, 0, 1, 2, 3, 4, 5, 6, 7, 8]'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class inversedB(gr.sync_block):  

          def __init__(self, ): 
              gr.sync_block.__init__(
                  self,
                  name='e_inversedB_ff',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              y[:]=np.power(10,x)
              return len(y)
  states: {state: bypassed}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '1'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: BER between Tx and Rx
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: bw*8
    fc: center_freq
    fftsize: '1024'
    name: '''before noise'''
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: after noise
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '6'
    ymin: '-7'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: Rx Bits
    size: ndisp
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    name: Tx Bits
    size: ndisp
    srate: samp_rate
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    label2: r4
    marker1: '0'
    marker2: '0'
    name: Compa bit
    nconnections: '2'
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_2_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    label1: t4
    marker1: '0'
    name: TX float to char 0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15
    size: 32*bps
    srate: samp_rate
    stemplot: 'True'
    type: float
    width1: '3'
    ymax: '15'
    ymin: '0'
  states: {}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: t
  states: {}
- name: virtual_sink_0_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: r
  states: {}
- name: virtual_source_0_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: r
  states: {}
- name: virtual_source_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: t
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_1_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0, '0']
- [analog_random_source_x_0, '0', blocks_repeat_0_0_0_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0_0_1_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0_1_0, '0', qtgui_time_sink_x_2_0_0_2_0, '0']
- [blocks_add_xx_1_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_char_to_float_0_0_1_0, '0', qtgui_time_sink_x_2_0_0, '1']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_char_to_float_0_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_2_0_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_delay_1_0_0_0_0, '0', blocks_skiphead_0_1, '0']
- [blocks_file_source_0, '0', blocks_repeat_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0_0_1_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [blocks_repeat_0_0_0_0, '0', blocks_char_to_float_0_2_0_0, '0']
- [blocks_repeat_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_skiphead_0_0_0, '0', blocks_char_to_float_0_0_1_0, '0']
- [blocks_skiphead_0_0_0, '0', fec_ber_bf_0_0, '1']
- [blocks_skiphead_0_1, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_skiphead_0_1, '0', fec_ber_bf_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_stream_to_vector_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle2_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_throttle2_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_repeat_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', virtual_sink_0_0_0_1_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_const_vxx_0_1_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_1, '0']
- [epy_block_0_0, '0', qtgui_number_sink_0_0, '0']
- [fec_ber_bf_0_0, '0', epy_block_0_0, '0']
- [logpwrfft_x_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0_0_0_0_0_0_0_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0_0_0_0_0_0_0_0, '0', blocks_skiphead_0_0_0, '0']
- [virtual_source_0_0_0_0_1_0, '0', blocks_delay_1_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
