options:
  parameters:
    author: clsor
    generate_options: qt_gui
    id: RX_evaluation_NF
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '868100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq-1500000
    fftsize: '1024'
    name: '"RX, Signal sent from TX"'
    type: complex
  states: {}
- name: soapy_hackrf_source_1
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    dev_args: driver=hackrf
    gain: '0'
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {}

connections:
- [soapy_hackrf_source_1, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
